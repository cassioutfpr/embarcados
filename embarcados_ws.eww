<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\EK-TM4C1294_IAR8\Projects\lab01\lab01.ewp</path>
    </project>
    <batchBuild />
</workspace>
